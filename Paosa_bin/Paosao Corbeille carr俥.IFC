Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Paosao Corbeille carrée.IFC
Time: 2020-07-01T12:01:37
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: PAO-COR-SUP-STRUC-MUL-V2-002_Default
In: Default Storey
PSet_Mass_Property - Mass Measure: 27.6702; Area Measure: 4.64356; Volume Measure: 0.00844399

# IfcBuildingElementProxy: 101222_Default
In: Default Storey
Material: PE
